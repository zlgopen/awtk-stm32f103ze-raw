# Keil uVision project awtk.uvproj, settings and files
target awtk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: awtk_demo1 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,NDEBUG, FAST_MODE,WITH_BITMAP_FONT,USE_GUI_MAIN,WITH_LOW_RES
  c include: ..\stm32f10x_fwlib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\user;..\core;..\app\led;..\app\beep;..\app\button;..\app\exti;..\app\iwdg;..\app\wwdg;..\app\tim;..\app\tpad;..\app\lcd;..\app\gui;..\USMART;..\app\rtc;..\app\wkup;..\app\adc;..\app\tsensor;..\app\dac;..\app\dma;..\app\AT24Cxx;..\app\IIC(24C02);..\app\spi;..\app\W25QXX;..\app\rs485;..\app\can;..\app\DS18B20;..\app\DHT11;..\app\adxl345;..\app\nrf24l01;..\app\stm32_flash;..\app\sram;..\app\malloc;..\app\SysTick;..\app\RTC_J;..\app\touch;..\awtk\src;..\awtk\3rd;..\awtk\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group system
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group fwlib
    ../stm32f10x_fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c
  group app
    ../app/led/: led.c
    ../app/lcd/: lcd_driver.c
    ../app/button/: button.c
    ../app/tim/: tim.c
    ../app/rtc/: rtc.c
    ../app/touch/: touch.c spi.c flash.c
    ../app/gui/: gui.c
  group awtk
    ../awtk/src/base/: array.c bitmap.c buffer.c button.c canvas.c check_button.c color.c dialog.c emitter.c enums.c font.c font_manager.c group_box.c image.c image_manager.c label.c lcd.c main_loop.c mem.c progress_bar.c rect.c theme.c utf8.c value.c widget.c widget_vtable.c window.c window_manager.c wstr.c utils.c events.c timer.c resource_manager.c layout.c event_queue.c slider.c window_animator.c idle.c time.c system_info.c image_loader.c locale.c str.c keyboard.c pages.c edit.c view.c velocity.c widget_factory.c
    ../awtk/src/font/: font_bitmap.c
    ../awtk/src/window_animators/: window_animator_null.c
    ../awtk/src/: tk.c
    ../awtk/src/main_loop/: main_loop_simple.c
  group awtk-port
    ../awtk-port/: lcd_stm32_raw.c main_loop_stm32_raw.c platform.c
    ../awtk/src/platforms/raw/: mutex_null.c sys_tick.c
  group awtk-demo
    ../awtk/demos/: demo_main.c demo1_app.c resource-mini.c
